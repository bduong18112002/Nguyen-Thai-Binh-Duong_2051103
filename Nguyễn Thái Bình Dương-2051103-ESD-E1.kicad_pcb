# Repository bduong18112002/Nguyen-Thai-Binh-Duong_2051103

File README.md:

# Nguyen-Thai-Binh-Duong_2051103
Nguyen Thai Binh Duong-2051103-ESD-E1

## KiCad design Nguyễn Thái Bình Dương-2051103-ESD-E1.kicad_pcb

Parts:
A1: Arduino_UNO_R2
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_0805_2012Metric
R1, R2, R3, R4, R5, R6, R7, R8: 247; R_0603_1608Metric

Connections:
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND)
unnamed: A1.5 (+5V), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1
unnamed: A1.17 (D2), D1.1 (K)
unnamed: A1.18 (D3), D2.1 (K)
unnamed: A1.19 (D4), D3.1 (K)
unnamed: A1.20 (D5), D4.1 (K)
unnamed: A1.21 (D6), D5.1 (K)
unnamed: A1.22 (D7), D6.1 (K)
unnamed: A1.23 (D8), D7.1 (K)
unnamed: A1.24 (D9), D8.1 (K)
unnamed: D1.2 (A), R8.2
unnamed: D2.2 (A), R7.2
unnamed: D3.2 (A), R6.2
unnamed: D4.2 (A), R5.2
unnamed: D5.2 (A), R4.2
unnamed: D6.2 (A), R3.2
unnamed: D7.2 (A), R2.2
unnamed: D8.2 (A), R1.2

Board: 2 copper layers, 17 parts (0 on the bottom side), 18 nets.
